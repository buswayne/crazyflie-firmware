## configs/tinympc_defconfig
```kconfig
CONFIG_PLATFORM_CF21BL=y

CONFIG_ESTIMATOR_AUTO_SELECT=y
CONFIG_CONTROLLER_TINYMPC=y
CONFIG_MOTORS_REQUIRE_ARMING=y
CONFIG_MOTORS_ESC_PROTOCOL_DSHOT=y
```
